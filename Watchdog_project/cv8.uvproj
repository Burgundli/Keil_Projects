# Keil uVision project cv8.uvproj, settings and files
target Target 1 (MCS-51)
  device: C8051F330 Silicon Labs
  cpu: IRAM(0-0xFF) XRAM(0-0x1FF) IROM(0-0x1FFF) CLOCK(25000000)
  output: cv8
  c flags: Optimize=8 SizeSpeed=1
  c include: C:\Silabs\MCU\INC
  group Source Group 1
    ./: main.c Untitled.c LM75D.c
