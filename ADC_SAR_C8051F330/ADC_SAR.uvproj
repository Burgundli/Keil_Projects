# Keil uVision project ADC_SAR.uvproj, settings and files
target Target 1 (MCS-51)
  device: C8051F330 Silicon Labs
  cpu: IRAM(0-0xFF) XRAM(0-0x1FF) IROM(0-0x1FFF) CLOCK(25000000)
  output: ADC_SAR +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: C:\SiLabs\MCU\INC
  group Source Group 1
    ./: main.c config.c
